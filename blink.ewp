# IAR project blink.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: D:\GITHUB\stm8-test; D:\GITHUB\stm8-test\STM8S_StdPeriph_Driver\inc; D:\GITHUB\stm8-test\STM8S_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group STM8S
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_gpio.c
  group User
    ./: main.c stm8s_it.c System.c
